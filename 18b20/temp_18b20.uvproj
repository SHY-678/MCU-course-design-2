# Keil uVision project temp_18b20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: temp_18b20 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51 temp_18b20_main.c
  group driver
    ./: nixie_tube.c ds18b20.c
